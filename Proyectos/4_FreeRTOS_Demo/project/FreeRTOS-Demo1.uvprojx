# Keil uVision project FreeRTOS-Demo1.uvprojx, settings and files
target FreeRTOS_Demo (ARM-ADS)
  device: STM32F407VG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: FreeRTOS-Demo1
  c flags: Optim=4 wLevel=2
  c define: USE_STDPERIPH_DRIVER STM32F4XX HSE_VALUE=8000000 KEIL_ARMCM4F
  c include: ..\src;..\src\FreeRTOS\include;..\src\FreeRTOS\portable\keil\ARM_CM4F;..\Utilities\STM32F4-Discovery;..\Libraries\CMSIS\Include;..\Libraries\Device\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../src/: debug.c main.c mems.c
  group FreeRTOS
    ../src/FreeRTOS/: croutine.c list.c queue.c tasks.c timers.c
    ../src/FreeRTOS/portable/keil/ARM_CM4F/: port.c
    ../src/FreeRTOS/portable/MemMang/: heap_1.c
  group StdPeriph Drivers
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group STM32F4
    ../src/: stm32f4_discovery_lis302dl.c stm32f4xx_it.c utils.c system_stm32f4xx.c
    ./: startup_stm32f4xx.s
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4_discovery.c
