# Keil uVision project plantilla.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: plantilla
  c flags: Optim=1 uC99=1
  c include: ..\..\Dependencias\trocito_biblioteca_stm32;..\..\Dependencias\STM32F4-Discovery_FW_V1.1.0\Libraries\CMSIS\ST\STM32F4xx\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x4000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f4xx.s main.c
  group parte
    ../../Dependencias/trocito_biblioteca_stm32/: stm32f4xx_gpio.c stm32f4xx_rcc.c
software components: CMSIS:CORE 4.1.0
